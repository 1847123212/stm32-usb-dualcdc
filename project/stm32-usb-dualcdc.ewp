# IAR project stm32-usb-dualcdc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427ZI ST STM32F427ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4; STM32F427xx; USE_HAL_DRIVER; USE_USB_HS
  ICCARM.CCIncludePath2: ..\app; ..\cfg; ..\dev; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\STM32F4xx\Include; ..\lib\STM32_USB_Device_Library\Class\CDC\Inc; ..\lib\STM32_USB_Device_Library\Core\Inc; ..\lib\STM32F4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32-usb-dualcdc.hex
  ILINK.IlinkOutputFile: stm32-usb-dualcdc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group app
    ../app/: dualcdc.c dualcdc.h main.c main.h
  group cfg
    ../cfg/: usbd_cdc_if.c usbd_cdc_if.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group dev
    ../dev/: startup_stm32f427xx.s stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group lib/STM32_USB_Device_Library/Class
    ../lib/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../lib/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group lib/STM32_USB_Device_Library/Core
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../lib/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group lib/STM32F4xx_HAL_Driver
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usb.c
    ../lib/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_ll_usb.h
